options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: inspector_vis3d_vf_0
  id: inspector_vis3d_vf
  parameters:
    fps: '3'
    gheight: '1'
    gwidth: '1'
    height: '1'
    maxz: '0'
    vlen: '1'
    width: '1'
    xaxis: X axis
    yaxis: Y axis
    zaxis: Z axis
  states: {}

connections:
- [analog_sig_source_x_0_0_0, '0', inspector_vis3d_vf_0, '0']

metadata:
  file_format: 1
